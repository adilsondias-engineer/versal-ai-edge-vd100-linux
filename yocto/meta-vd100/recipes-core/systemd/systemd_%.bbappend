PACKAGECONFIG:append = " timesyncd"